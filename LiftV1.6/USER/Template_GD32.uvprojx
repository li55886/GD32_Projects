# Keil uVision project Template_GD32.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -DGD32F40X
  c include: ..\USER;..\CORE;..\FWLIB\inc;..\SYSTEM\sys;..\SYSTEM\delay;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\GPIO;..\HARDWARE\USART;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\MOTOR;..\BLL;..\MODBUS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c gd32f4xx_it.c system_gd32f4xx.c
  group CORE
    ../CORE/: startup_gd32f407.s
  group FWLIB
    ../FWLIB/src/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_misc.c
  group HARDWARE
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
  group BLL
    ../BLL/: bll_main.c bll_motor.c bll_access.c bll_adapter.c bll_backzero.c bll_eeprom.c bll_tocase.c
  group MODBUS
    ../MODBUS/: modbus_master.c modbus_slave.c modbus_save_data.c
