# Keil uVision project Template.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F40X,USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\inc;..\USER;..\HARDWARE\TIMER;..\HARDWARE\USART;..\HARDWARE\GPIO;..\HARDWARE\EXTI;..\HARDWARE\IWDG;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\MODBUS;..\BLL;..\HARDWARE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c gd32f4xx_it.c system_gd32f4xx.c
  group CORE
    ../CORE/: startup_gd32f407.s
  group FWLIB
    ../FWLIB/src/: gd32f4xx_misc.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_gpio.c gd32f4xx_fwdgt.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_usart.c gd32f4xx_pmu.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/GPIO/: gpio.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
  group MODBUS
    ../MODBUS/: modbus_slave.c modbus_master.c modbus_save_data.c
  group BLL
    ../BLL/: bll_main.c bll_adapter.c bll_backzero.c bll_eeprom.c bll_motor.c bll_tocase.c bll_claw.c bll_access.c
